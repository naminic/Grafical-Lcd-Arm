# Keil uVision project main.uvproj, settings and files
target flash-SAM-ICE (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: at91sam7x256-flash
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 flash NOFPUT
  c misc: --gnu
  c include: ../../../at91lib/peripherals;../../../at91lib;../../../at91lib/components;../../../at91lib/boards/at91sam7x-ek;..\..\..\at91lib\utility
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/flash.sct
  link misc: --entry resetHandler
  group at91lib
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../../at91lib/peripherals/dbgu/: dbgu.c
    ../../../at91lib/peripherals/pmc/: pmc.c
    ../../../at91lib/boards/at91sam7x-ek/: board_lowlevel.c board_memories.c board_cstartup_keil.s
    ../../../at91lib/utility/: retarget.c glcd.c
    ../../../at91lib/peripherals/pio/: pio.c
    ../../../at91lib/peripherals/aic/: aic.c
    ../../../at91lib/peripherals/pit/: pit.c
    ../../../at91lib/peripherals/ssc/: ssc.c
    ../../../at91lib/peripherals/adc/: adc.c
  group Files
    ../: main.c
target sram-SAM-ICE (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: as above
  output: at91sam7x256-sram
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 sram NOFPUT
  c misc: --gnu
  c include: ../../../at91lib/peripherals,../../../at91lib,../../../at91lib/components,../../../at91lib/boards/at91sam7x-ek
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/sram.sct
  link misc: --entry resetHandler
target flash-ULINK (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: as above
  output: at91sam7x256-flash
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 flash NOFPUT
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/flash.sct
  link misc: --entry resetHandler
target sram-ULINK (ARM-ADS)
  device: at91sam7x256 Atmel
  cpu: as above
  output: at91sam7x256-sram
  AfterMake: fromelf.exe --bin -o  $L@L.bin #L
  c flags: Optim=1
  c define: at91sam7x256 sram NOFPUT
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: ../../../at91lib/boards/at91sam7x-ek/at91sam7x256/sram.sct
  link misc: --entry resetHandler
